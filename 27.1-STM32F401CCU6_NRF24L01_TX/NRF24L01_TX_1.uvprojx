# Keil uVision project NRF24L01_TX_1.uvprojx, settings and files
target NRF24L01_TX_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF24L01_TX_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx, USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\src;.\core;.\lib;.\Include;..\00-STM32F446RE_LIBRARIES
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f401xx.s
  group Source
    ./src/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    ../00-STM32F446RE_LIBRARIES/: lvq_stm32f4_defines.h
  group STD_Lib
    ./lib/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_dma.c
  group LVQ
    ../00-STM32F446RE_LIBRARIES/: lvq_stm32f4_rccConfig.c lvq_stm32f4_gpio.c lvq_stm32f4_usart.c lvq_stm32f4_spi.c lvq_stm32f4_adc.c lvq_stm32f4_dac.c lvq_stm32f4_i2c.c lvq_stm32f4_lcd.c lvq_stm32f4_ds1307.c lvq_stm32f4_exti.c lvq_stm32f4_rtc.c lvq_stm32f4_pwm.c lvq_stm32f4_keypad.c lvq_stm32f4_delay.c lvq_stm32f4_dma.c lvq_stm32f4_usart_dma.c lvq_stm32f4_mpu6050.c lvq_stm32f4_pwm_dma.c lvq_stm32f4_buttons.c lvq_stm32f4_crc.c lvq_stm32f4_gps.c lvq_stm32f4_ssd1306.c lvq_stm32f4_fonts.c lvq_stm32f4_nrf24.c lvq_stm32f4_adc_dma.c lvq_stm32f4_oledmenu.c lvq_stm32f4_uitx.c
