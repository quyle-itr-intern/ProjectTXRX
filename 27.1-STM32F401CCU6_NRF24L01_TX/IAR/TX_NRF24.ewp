# IAR project TX_NRF24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F446xx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: E:\Downloads\STM32F4\STM32F446RE_REG\27.1-STM32F401CCU6_NRF24L01_TX\core; E:\Downloads\STM32F4\STM32F446RE_REG\27.1-STM32F401CCU6_NRF24L01_TX\Include; E:\Downloads\STM32F4\STM32F446RE_REG\27.1-STM32F401CCU6_NRF24L01_TX\lib; E:\Downloads\STM32F4\STM32F446RE_REG\27.1-STM32F401CCU6_NRF24L01_TX\src; E:\Downloads\STM32F4\STM32F446RE_REG\27.1-STM32F401CCU6_NRF24L01_TX\startup; E:\Downloads\STM32F4\STM32F446RE_REG\00-STM32F446RE_LIBRARIES
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TX_NRF24.srec
  ILINK.IlinkOutputFile: TX_NRF24.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group LVQ
    ../../00-STM32F446RE_LIBRARIES/: lvq_stm32f4_adc.c lvq_stm32f4_adc_dma.c lvq_stm32f4_delay.c lvq_stm32f4_fonts.c lvq_stm32f4_gpio.c lvq_stm32f4_i2c.c lvq_stm32f4_nrf24.c lvq_stm32f4_ssd1306.c lvq_stm32f4_uitx.c
  group src
    ../src/: main.c main.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group STD
    ../../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_i2c.c
